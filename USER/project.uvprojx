# Keil uVision project project.uvprojx, settings and files
target STM324G (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4-4G +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\HARDWARE\SRAM;..\HARDWARE\ADC;..\FWLIB\inc;..\IAP;..\4G;..\FLASH;..\FWLIB;..\HARDWARE\FSR;..\HARDWARE\Motor;..\HARDWARE\MQTT;..\HARDWARE\SERVO;..\FWLIB\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SRAM/: sram.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_adc.c stm32f4xx_spi.c
    ../FWLIB/: jpeg.lib
  group IAP
    ../IAP/: iap.c stmflash.c crc16.c
  group 4G
    ../4G/: 4g.c
  group FLASH
    ../FLASH/: spi_flash.c
  group Motor
    ../HARDWARE/Motor/: Motor.c Motor.h
  group MQTT
    ../HARDWARE/MQTT/: MQTT.c MQTT.h
  group SERVO
    ../HARDWARE/SERVO/: SERVO.c SERVO.h
